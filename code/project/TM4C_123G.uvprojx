# Keil uVision project TM4C_123G.uvprojx, settings and files
target TM4C_123G (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TM4C_123G +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c include: ..\lib;..\src\mian;..\src\led;..\lib\freeRTOS\portable\RVDS\ARM_CM4F;..\lib\freeRTOS\portable\MemMang;..\lib\freeRTOS\include;..\src\config;..\src\tasks;..\src\sensors;..\src\drives;..\src\communicate;..\src\system\delay;..\src\system\usart;..\src\system\system_Init;..\src\math;..\src\control
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ../src/mian/: main.c
    ./: startup_rvmdk.S
  group config
    ../src/config/: config.h runtime_config.h runtime_config.c
    ../lib/freeRTOS/include/: FreeRTOSConfig.h
  group control
    ../src/control/: pid.c state_control.c power_control.c rc_controls.c pos_estimator.c safe_control.c alt_control.c posXY_control.c
  group tasks
    ../src/tasks/: led_task.c sensors_task.c stabilizer_task.c usart_task.c config_param.c fsrx_task.c position_task.c
  group sensors
    ../src/sensors/: mpu6500.c gyro.c accelerometer.c sensorsalignment.c us100_height.c optical_position.c open_mv.c TOF_height.c ANO_optical.c
  group drives
    ../src/drives/: key.c led.c motor.c myadc.c myiic.c Time_Cnt.c user_Ringbuf.c tiva_flash.c spi_master.c US_100.c pmw3901.c
  group communicate
    ../src/communicate/: atkp.c cppm.c commander.c
  group common
    ../src/math/: maths.c filter.c imu.c kalmanFilter.c
  group system
    ../src/system/delay/: delay.c
    ../src/system/usart/: usart.c
    ../src/system/system_Init/: system_Init.c
  group inc
    ../lib/inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lcd.h hw_memmap.h hw_nvic.h hw_onewire.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h tm4c123gh6pm.h
  group driverlib
    ../lib/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group utils
    ../lib/utils/: uartstdio.c
  group freeRTOS_CORE
    ../lib/freeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group freeRTOS_PORTABLE
    ../lib/freeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../lib/freeRTOS/portable/MemMang/: heap_4.c
